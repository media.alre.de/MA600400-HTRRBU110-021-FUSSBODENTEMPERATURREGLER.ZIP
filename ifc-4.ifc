Properties of the parts of a building model (IFC4)

# File
Description: Fußbodentemperaturregler mit Uhr, Aufputz, Fernfühler NTC 2K, Hintergrundbeleuchtung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA600400, Fußbodentemperaturregler mit Uhr, Aufputz, Fernfühler NTC 2K, Hintergrundbeleuchtung
In: Raum
Description: Elektronischer Fußbodentemperaturregler zur zeitabhängigen Regelung von Temperaturen in geschlossenen Räumen. Geeignet für Fußboden-, Randzonen-, Badezimmer-, Decken-, Kachelofen-, Marmor- und Wandheizungen bzw. Temperiersysteme bis zu 3000 W. Kann als Master (Pilotregler) zur Temperaturabsenkung anderer Regler eingesetzt werden. Hierzu sind Regler der Typenreihe FETR, FTR und RTBSB als Slaves (Satellitenregler) geeignet. Einfachste Bedienung durch Direktwahltasten. Bei Fühlerbruch oder Fühlerkurzschluss wird die Heizung mit einer Einschaltdauer von 30 % angesteuert um ein Auskühlen oder Frostschäden im Raum zu vermeiden. Bei Temperaturen unter –20 °C werden ebenfalls als Fühlerbruch ausgewertet und die Notlauffunktion ausgelöst. Die Montage kann mittels Adapterplatte auch auf eine UP-Dose erfolgen.; Classification: EC011309 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA600400; ModelLabel: HTRRBu110.021; GlobalTradeItemNumber: 4050528050137; ProductURL: https://alre.de/produkt_MA600400
Pset_Specification - NominalLength: 0.1107 m; NominalWidth: 0.11 m; NominalDepth: 0.026 m; NetWeight: 0.34
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 110; Höhe: 110.7; Tiefe: 26; RAL-Nummer: 9010; Anschluss: sonstige; Mit thermischer Rückführung: no; Art der Spannungsversorgung: 230 V; Kontaktausführung: Schließer (NO); Messbereich: 10; Bedienung: Dreh; Explosionsgeschützt: no; Uhrentyp: Wochenuhr; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Witterungsabhängige Regelung: no; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 0; Ausführung Uhr: digital; Wahlschalter für Heizung und Warmwasser mit Heizung: no; Überstundenschalter: yes; Temperatur ablesbar: yes; Optimierung: yes; Anzahl der Schaltprogramme: 7; Max. Kontaktbelastung: 13; Differenzwert: 1; Sensor extern: yes; Differenz verstellbar: no; Geeignet für Heizung: yes; ETIM-Klasse: EC011309; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA600400.pdf
